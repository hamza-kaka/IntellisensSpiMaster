# Keil uVision project IntellisensSpiMaster.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FN2M0xxx18 NXP
  pack: NXP.MK66F18_DFP.13.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IntellisensSpiMaster
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK66FN2M0VLQ18
  c misc: --asm
  c include: .\board;..\..\CMSIS\Include;..\..\devices\MK66F18;..\..\devices\MK66F18\drivers;..\..\devices\MK66F18\arm;..\..\devices\MK66F18\utilities;..\..\devices\MK66F18\utilities\str;..\..\devices\MK66F18\utilities\debug_console;..\..\TestingFiles;..\..\SpiCommunication;..\..\I2Commands;..\..\HelpingModules;..\k66;..\..\components\serial_manager;..\..\spiApp;..\..\application
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\devices\MK66F18\arm\MK66FN2M0xxx18_flash.scf
  group app
    ./: mainApp.c
    ../../spiApp/: spiParams.h spiTestApp.c
  group board
    ./board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../devices/MK66F18/drivers/: fsl_adc16.c fsl_adc16.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lmem_cache.c fsl_lmem_cache.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sdramc.c fsl_sdramc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_tpm.c fsl_tpm.h fsl_tsi_v4.c fsl_tsi_v4.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group startup-system
    ../../devices/MK66F18/: MK66F18.h system_MK66F18.c system_MK66F18.h
    ../../devices/MK66F18/arm/: startup_MK66F18.s
  group spiComm
    ../../SpiCommunication/: spiComm.c spiComm.h
  group I2Commands
    ../../I2Commands/: I2Commands.c I2Commands.h
  group helpingModules
    ../../HelpingModules/: dma.c dma.h timers.c timers.h gpio.c gpio.h
  group testModes
    ../../TestingFiles/: TestMode1.c TestMode2.c TestMode3.c TestMode4.c
  group userConfig
    ../: UserConfig.h
